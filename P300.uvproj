# Keil uVision project P300.uvproj, settings and files
target Target 1 (166/167)
  device: XC2364B-40F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE01FFF) XRAM3(0x00F600-0x00FDFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC4FFFF) CLOCK(80000000) MOD167 MODV2
  output: P300 +hex
  group driver
    ./src/driver/: ADC0.c ADC1.c CAN.c CCU61.c GPT1.c GPT2.c IO.c RTC.c SCS.c MAIN.c Start_V3.A66
  group mode
    ./src/app/mode control/: ModeControl.c
  group alogrithm
    ./src/app/alogrithm/: booster.c energy_recovery.c pid.c wire_control.c
  group app
    ./src/app/adc/: adc_sample.c adc_sample.h
    ./src/app/ccp/: ccp.c
    ./src/app/diagnostic/: FLTD.c
    ./src/app/rtos/: osapi.c
    ./src/app/rte/: rte.c rte.h
    ./src/interaction/: EEPROM_Cfg.h
  group interaction
    ./src/interaction/: adc_if.c ccp_if.c eepRom.c pwm.c
  group task
    ./src/app/task/: Task1.c Task2.c Task3.c Task4.c
  group can
    ./src/app/can/: can_com.c can_diag.c can_com.h
    ./src/bsw/can/: can_if.c
  group desc
    ./src/bsw/desc/: desc.c desc_mgr.c desc_ser.c
  group nm
    ./src/bsw/nm/: nm.c
  group time_measure
    ./src/app/time measure/: time_measure.c
